# Keil uVision project SkyPulse.uvprojx, settings and files
target SkyPulse (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F405VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: SkyPulse +hex
  AfterMake: pproc.bat
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F405xx, __REENT=1
  c misc: --exceptions
  c include: ../Inc;                                                                                                                                                                  ../Drivers/STM32F4xx_HAL_Driver/Inc;                                                                                                                                                                  ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;                                                                                                                                                                  ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;                                                                                                                                                                  ../Middlewares/Third_Party/FatFs/src;                                                                                                                                                                  ../Drivers/CMSIS/Include;                                                                                                                                                                  ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;                                                                                                                                                                  ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;                                                                                                                                                                  ..\..\C\Inc;                                                                                                                                                                  ..\..\Cpp\Inc;                                                                                                                                                                  ..\..\lcd\src;                                                                                                                             ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;                                                                                                                             ../Middlewares/Third_Party/FreeRTOS/Source/include;                                                                                                                             ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS
  asm include: ..\Inc;..\\Inc
  memory RVCT4: ROM 0x8008000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../../C/Src/: printf_stdarg.c
    ../Src/: system_stm32f4xx.c
  group Application/MDK-ARM
    ./: startup_stm32f405xx.s
  group Application/User
    ../Src/: main.c freertos.c user_diskio.c fatfs.c usb_device.c usbd_conf.c usbd_desc.c usbd_cdc_if.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group C
    ../../C/Src/: io.c proc.c retarget.c misc.c
    ../../lcd/Objects/: lcd.lib
  group Cpp
    ../../Cpp/Src/: term.cpp ioc.cpp can.cpp adc.cpp pump.cpp fan.cpp cli.cpp spray.cpp rtc.cpp ws2812.cpp fit.cpp fsw.cpp dl.cpp
    ../../: info.txt
    ./: test.cpp
  group Simulator
    ../../Cpp/Src/: Simulator.cpp
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_crc.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c ccsbcs.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
software components: CMSIS:CORE 5.0.1
